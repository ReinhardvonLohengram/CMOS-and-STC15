# Keil uVision project main.uvproj, settings and files
target Target (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Lab5 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\delay;..\GUI;..\HARDWARE\spi;..\HARDWARE\xpt2046;..\MAIN;..\tft;..\HARDWARE\key;..\HARDWARE\sd;..\FATFS;..\HARDWARE\flash;..\HARDWARE\sram;..\OV7670
  group main
    ./: main.c
  group delay
    ../delay/: delay.c
  group tft
    ../tft/: tft.C
  group GUI
    ../GUI/: GUI.C
  group HARDWARE
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/xpt2046/: xpt2046.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/sd/: sd.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/sram/: sram.c
  group FATFS
    ../FATFS/: diskio.c pff.c
  group ov7670
    ../OV7670/: ov7670.c sccb.c
